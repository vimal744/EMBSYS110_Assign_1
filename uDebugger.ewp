# IAR project uDebugger.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401xE ST STM32F401xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F401xx
  ICCARM.CCIncludePath2: .\; Util; BSP; BSP\CMSIS; BSP\ST\StdPeripheralDrivers; Task; Types
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uDebugger.sim
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: BSP\layout.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group App
    App/: main.c
  group BSP
    BSP/: bsp.h datainit.c debugger.c hw_init.c hw_init.h interrupt.c layout.icf nucleoboard.h startup.s uart.c uart.h
  group BSP/CMSIS
    BSP/CMSIS/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h stm32f4xx.h system_stm32f4xx.h
  group BSP/ST/StdPeripheralDrivers
    BSP/ST/StdPeripheralDrivers/: misc.c misc.h stm32f4xx_conf.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_usart.c stm32f4xx_usart.h
  group Task
    Task/: task_cs.c TASK_pub.h
  group Types
    Types/: TYPS_pub.h
  group Util
    Util/: print.c print.h
